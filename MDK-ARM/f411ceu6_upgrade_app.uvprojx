# Keil uVision project f411ceu6_upgrade_app.uvprojx, settings and files
target f411ceu6_upgrade_app (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08010000-0x0805FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: f411ceu6_upgrade_app
  AfterMake: "$KARM\ARMCC\bin\fromelf.exe" --bin --output ".\f411ceu6_upgrade_app\f411ceu6_upgrade_app.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,USER_VECT_TAB_ADDRESS,VECT_TAB_OFFSET=0x10000
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/FreeRTOS/include;../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F;../Middlewares/LVGL;../Middlewares/LVGL/lvgl;../Middlewares/LVGL/lvgl/examples/porting;../interface;../application;../common
  memory RVCT4: ROM 0x8010000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\f411ceu6_upgrade_app_flash_safe.sct
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group application
    ../application/: app_weather.c app_weather.h app_battery.c app_battery.h app_aht21.c app_aht21.h app_heart.c app_heart.h app_clock.c app_clock.h app_diag.c app_reset.c app_reset.h app_ota.c app_ota.h app_reset_ble.c app_reset_ble.h app_touch.c app_touch.h app_task.c app_task.h app_display.c app_display.h app_ui.c app_ui.h app_ble_service.c app_ble_service.h ui_widgets.c ui_widgets.h ui_sydney_font.c app_imu.c app_imu.h app_imu_store.c app_mag_store.c app_tickless.c app_uptime.c app_weather_store.c app_battery_log.c app_battery_log_ble.c app_mag_store.h app_baro.c app_baro.h
  group interface
    ../interface/: tps3823.c tps3823.h aht21.c aht21.h em7028.c em7028.h watch_rtc.c watch_rtc.h kt6368a.c kt6368a.h lcd.c lcd.h touch.c touch.h mpu6050.h mpu6050.c spl006.c spl006.h lsm303dlhc.c lsm303dlhc.h bl24c02.c battery_adc.c watch_key.c int_battery_log.c bl24c02.h
  group Middlewares/FreeRTOS
    ../Middlewares/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/FreeRTOS/portable/: heap_4.c
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LVGL
    ../Middlewares/LVGL/lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
    ../Middlewares/LVGL/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Middlewares/LVGL/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares/LVGL/lvgl/src/draw/nxp_pxp/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../Middlewares/LVGL/lvgl/src/draw/nxp_vglite/: lv_gpu_nxp_vglite.c
    ../Middlewares/LVGL/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Middlewares/LVGL/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Middlewares/LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../Middlewares/LVGL/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Middlewares/LVGL/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Middlewares/LVGL/lvgl/src/extra/: lv_extra.c
    ../Middlewares/LVGL/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Middlewares/LVGL/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Middlewares/LVGL/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Middlewares/LVGL/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Middlewares/LVGL/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Middlewares/LVGL/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/led/: lv_led.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/list/: lv_list.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/span/: lv_span.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/win/: lv_win.c
    ../Middlewares/LVGL/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../Middlewares/LVGL/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Middlewares/LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Middlewares/LVGL/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Middlewares/LVGL/demos
    ../Middlewares/LVGL/lvgl/demos/stress/: lv_demo_stress.c
    ../Middlewares/LVGL/lvgl/demos/stress/assets/: lv_font_montserrat_12_compr_az.c lv_font_montserrat_16_compr_az.c lv_font_montserrat_28_compr_az.c
    ../Middlewares/LVGL/lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../Middlewares/LVGL/lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
  group common
    ../common/: my_i2c.c platform_delay.c my_i2c.h common_imu.c common_mag_cal.c common_activity.c common_imu.h
software components: CMSIS:CORE 4.3.0
