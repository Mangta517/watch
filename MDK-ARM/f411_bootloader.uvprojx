# Keil uVision project f411_bootloader.uvprojx, settings and files
target f411_bootloader (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x08007FFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: f411_bootloader
  AfterMake: "$KARM\ARMCC\bin\fromelf.exe" --bin --output ".\bootloader\f411_bootloader.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,F411_BOOTLOADER
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/FreeRTOS/include;../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F;../Middlewares/LVGL;../Middlewares/LVGL/lvgl;../Middlewares/LVGL/lvgl/examples/porting;../interface;../application;../common
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Bootloader
    ./: startup_stm32f411xe.s
    ../Core/Src/: stm32f4xx_hal_msp.c system_stm32f4xx.c
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
    ../bootloader/: boot_main.c boot_platform.c
    ../application/: app_boot_select.c
    ../interface/: bl24c02.c
    ../common/: my_i2c.c platform_delay.c
software components: CMSIS:CORE 4.3.0
